# Keil uVision project IF_ELSE.uvproj, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::..\..\Keil_v5\ARM\ARMCC)
  device: LPC2378 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: IF_ELSE
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Group 1
    ./: Main_Code_1.s
  group Source Group 2
    ./: Main_Code_2.s
